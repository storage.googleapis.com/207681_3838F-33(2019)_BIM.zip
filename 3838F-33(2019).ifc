Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-01T13:44:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 01 13:44:32 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{8D183A0D-EEB0-4BF1-A521-C11A61BD3EA0}\ifc * Database version: 5507 * Database creation date: Mon Mar 01 13:44:32 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 01 13:44:32 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 01 13:44:32 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3838F-33 Kitchen faucet, 3838F-33(2019):3838F-33 Kitchen faucet:353091
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 232.79 mm; NominalHeight: 298.727 mm; NominalWidth: 101.194 mm; Projection: 193 mm
Type - General - Author: BIMStone; BIMObjectName: 3838F-33(2019); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 23/02/2021
Type - Green Building Properties - Customs Code: 84818011; EAN Number: 6414150096181; EN Standard: EN 817; NRF Number: 4200452; RSK Number: 8311364; VVS Number: 706024311
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/3838F-33; Class: Side operated; Dimension Drawing URL: http://static.oras.com/dimdrw/3838F-33; FDV Document URL: http://www.oras.com/datasheet/3838F-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3838F-33; Group: Kitchen faucets; Manufacturer: Oras; Market: INT;NOR;SWE;DNK;POL;RUS;LTU;LVA;UKR; Model: 3838F-33 Kitchen faucet; Name_en: 3838F-33 Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 407 x 265 x 119; Package Weight: 2.719 kg; Product Code: 3838F-33; Product Datasheet: http://www.oras.com/datasheet/3838F-33/en; Product Family: Oras Twista; Product Image URL: http://static.oras.com/image/3838F-33; Product URL: http://static.oras.com/3838F-33; Technical DataSheet URL: http://www.oras.com/datasheet/3838F-33/en; Type Name: 3838F-33 Kitchen faucet
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: DZR brass;Low lead <0.3;Waterways without nickel coating;; Aerator: CASCADE®; Connection: FlexibleInletPipes; Connection Size: G3/8; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: http://static.oras.com/manual/3838F-33; Installation Type: Deck mounted; Lever Handle: ;Lever with H+C symbol; Max. Hot Water Supply: 90 kg/K/s3; Mechanical Parts: 35Cartridge; Mounting Holes: 1MountingHole; Pressure Loss With Flow 02ls: 300000 Pa; Spare Parts: http://static.oras.com/sp/3838F-33; Spout Swivel Range: 150° (360°); Spout Type: Swivel spout; Temperature Adjustments: Temperature limiter
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3838F-33(2019); Features: Side operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3838F-33; Name: 3838F-33 Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 100x255x300 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.124426 m2; Volume: 0.00704179 m3
Identity Data - Mark: 9
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 3838F-33(2019): 3838F-33 Kitchen faucet; Family and Type: 3838F-33(2019): 3838F-33 Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3838F-33(2019): 3838F-33 Kitchen faucet; Type Id: 3838F-33(2019): 3838F-33 Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
